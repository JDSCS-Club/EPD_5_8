# IAR project Backup (7) of Project.ewp, settings and files
configuration STM324xG_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\CMSIS\Device\ST\STM32F4xx; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\BSP\STM324xG_EVAL; ..\Drivers\BSP; ..\Middlewares\Third_Party\LwIP\src; ..\Middlewares\Third_Party\LwIP\system; ..\Utilities; ..\Utilities\Log; ..\Middlewares\Third_Party\LwIP\src\include; ..\Src; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Middlewares\Third_Party\LwIP\src\include\lwip; ..\Drivers\display; ..\Drivers\display\fonts; ..\Drivers\display\OLED; ..\Drivers\display\GUI; ..\Drivers\display\Example; ..\Drivers\display\Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: 336_FDI.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: AmpGpio.c app_ethernet.c CRC8.c debug_task.c ethernetif.c Flash.c I2C.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c tcp_echoserver.c Timer.c udp_echoclient.c USRAT.c WWDG.c
  group Application/Utilities/Fonts
    ../Utilities/Fonts/: font12.c font12CN.c font16.c font20.c font24.c font24CN.c font8.c fonts.h
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ili9325/: ili9325.c
    ../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM324xG_EVAL
    ../Drivers/BSP/STM324xG_EVAL/: stm324xg_eval.c stm324xg_eval_io.c stm324xg_eval_sram.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/display/Config
    ../Drivers/display/Config/: DEV_Config.c
  group Drivers/display/Example
    ../Drivers/display/Example/: ImageData.c OLED_0in91_test.c OLED_0in95_rgb_test.c OLED_0in96_test.c OLED_1in3_c_test.c OLED_1in3_test.c OLED_1in5_rgb_test.c OLED_1in5_test.c test.h
  group Drivers/display/GUI
    ../Drivers/display/GUI/: GUI_Paint.c
  group Drivers/display/OLED
    ../Drivers/display/OLED/: OLED_0in91.c OLED_0in95_rgb.c OLED_0in96.c OLED_1in3.c OLED_1in3_c.c OLED_1in5.c OLED_1in5_rgb.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fsmc.c
  group Middlewares/LwIP/Api
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/Core
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/Core/IPv4
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/Netif
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
